# IAR project Template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC126AE series Nuvoton NUC126AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\NUC126\Include; ..\..\..\Library\CMSIS\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: Template.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../Library/Device/Nuvoton/NUC126/Source/IAR/: startup_NUC126.s
    ../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
  group Library Files
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group Source Files
    ../: main.c
